Commit message: RIGID BODY COLLISION

File: general/general.urdf (robot description, URDF)
Before this commit: robot rigid_body_cube, 1 links, 0 joints
Links:
- link base_link: geometry collision mesh filename=package://cube.obj scale=2 2 2; visual mesh filename=package://cube.obj scale=2 2 2
